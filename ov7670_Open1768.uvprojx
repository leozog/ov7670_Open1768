# Keil uVision project ov7670_Open1768.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ov7670_Open1768
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: ov7670_LPC1768.h asciiLib.c asciiLib.h lcd_ctrl.c lcd_ctrl.h LCD_ILI9325.c LCD_ILI9325.h main.c Open1768_LCD.c Open1768_LCD.h ov7670.c ov7670.h ov7670_LPC1768.c menu.h menu.c sender.h sender.c uart.c uart.h
software components: CMSIS:CORE 5.6.0, CMSIS Driver:I2C 2.6.0, Device:GPDMA 1.2.0, Device:PIN 1.0.0, Device:Startup 1.0.0
